# Keil uVision project SmartBox.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SmartBox +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --diag_suppress=870
  c include: ..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\User\BSP;..\User\APP;..\Libraries\irmp
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../User/BSP/: system_stm32f10x.c
  group RVMDK
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
  group BSP
    ../User/BSP/: bsp.c BspTime2.c BspTime3.c BspUsart1.c InOutControl.c Lcd12864.c key.c NRF522.c bsp_timer.c rtc.c roomInfoManage.c beep.c w25qxx.c
  group APP
    ../User/APP/: main.c menu.c
